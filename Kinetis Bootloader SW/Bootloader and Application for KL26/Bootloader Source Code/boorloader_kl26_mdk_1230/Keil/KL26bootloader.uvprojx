# Keil uVision project KL26bootloader.uvprojx, settings and files
target KL26bootloader (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: KL26bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Common;..\Driver\bootcfg;..\Driver\flash;..\Driver\rs232;..\Sources;..\Startup_Code;..\..\boorloaderMDK;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x2ff8
  group Common
    ../Common/: core_cm0plus.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h MKL26Z4.h system_MKL26Z4.h bootloader_asm.s
  group Driver
    ../Driver/bootcfg/: FRDM_KL26Z_cfg.h
    ../Driver/flash/: flash_kinetis.c flash_kinetis.h
    ../Driver/rs232/: rs232.c rs232.h
  group Sources
    ../Sources/: bootloader.c bootloader.h
  group Startup_Code
    ../Startup_Code/: startup_MKL26Z4.S system_MKL26Z4.c
