# IAR project KL26bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z128xxx4 Freescale MKL26Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM0PLUS; MKL26Z4
  ICCARM.CCIncludePath2: ..\Common; ..\Driver\bootcfg; ..\Driver\flash; ..\Driver\rs232; ..\Sources; ..\Startup_Code; ..; ..\Driver; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KL26bootloader.bin
  ILINK.IlinkOutputFile: KL26bootloader.out
  ILINK.IlinkIcfFile: ..\MKL26Z128xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: MKL26Z128xxx4.icf
  group Common
    ../Common/: core_cm0plus.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h MKL26Z4.h system_MKL26Z4.h
  group Driver/bootcfg
    ../Driver/bootcfg/: FRDM_KL26Z_cfg.h
  group Driver/flash
    ../Driver/flash/: flash_kinetis.c flash_kinetis.h
  group Driver/rs232
    ../Driver/rs232/: rs232.c rs232.h
  group Sources
    ../Sources/: bootloader.c bootloader.h
  group Startup_Code
    ../Startup_Code/: startup_MKL26Z4.S system_MKL26Z4.c
