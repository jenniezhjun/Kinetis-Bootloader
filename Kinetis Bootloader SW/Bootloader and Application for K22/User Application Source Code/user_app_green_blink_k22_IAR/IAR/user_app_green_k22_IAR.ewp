# IAR project user_app_green_k22_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\Common; ..\Sources; ..\Startup_Code
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: user_app_green_k22_IAR.hex
  ILINK.IlinkOutputFile: user_app_green_k22_IAR.out
  ILINK.IlinkIcfFile: C:\Users\B55335\Desktop\boot0106\Kbootloader\Bootloader and Application for K22\User Application Source Code\user_app_green_k22_IAR\MK22xX512_12.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: MK22xX512_12.icf
  group Common
    ../Common/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_cmSimd.h MK22F51212.h system_MK22F51212.h
  group Sources
    ../Sources/: bl_communication.c bl_communication.h main.c
  group Startup_Code
    ../Startup_Code/: startup_MK22F51212.S system_MK22F51212.c
