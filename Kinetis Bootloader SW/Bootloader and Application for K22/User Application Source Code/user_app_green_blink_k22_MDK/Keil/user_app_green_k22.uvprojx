# Keil uVision project user_app_green_k22.uvprojx, settings and files
target user_app_green_k22 (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: user_app_green_k22 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Common;..\Sources;..\Startup_Code;..\Keil;.\Objects;.\Listings
  memory RVCT4: ROM 0x4000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xfff8
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Common
    ../Common/: core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h MK22F51212.h system_MK22F51212.h
  group Sources
    ../Sources/: bl_communication.c bl_communication.h main.c
  group Startup_Code
    ../Startup_Code/: startup_MK22F51212.S system_MK22F51212.c
