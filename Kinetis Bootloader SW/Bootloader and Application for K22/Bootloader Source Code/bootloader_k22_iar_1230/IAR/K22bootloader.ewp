# IAR project K22bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK22FN12
  ICCARM.CCIncludePath2: ..\Common; ..\Driver; ..\Driver\bootcfg; ..\Driver\flash; ..\Driver\rs232; ..\Sources; ..\Startup_Code; ..\..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: K22bootloader.s19
  ILINK.IlinkOutputFile: K22bootloader.out
  ILINK.IlinkIcfFile: C:\Users\B55335\Desktop\github\Kinetis-Bootloader\Kbootloader\Bootloader and Application for K22\Bootloader Source Code\bootloaderIAR1211\MK22xX512_12.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common
    ../Common/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_cmSimd.h MK22F51212.h system_MK22F51212.h
  group Diver/bootcfg
    ../Driver/bootcfg/: FRDM_K22F_cfg.h
  group Diver/flash
    ../Driver/flash/: flash_kinetis.c flash_kinetis.h
  group Diver/rs232
    ../Driver/rs232/: rs232.c rs232.h
  group Sources
    ../Sources/: bootloader.c bootloader.h
  group Startup_Code
    ../Startup_Code/: startup_MK22F51212.S system_MK22F51212.c
